<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\emb_osc_brake_timerb.ewp</path>
  </project>
  <batchBuild/>
</workspace>


