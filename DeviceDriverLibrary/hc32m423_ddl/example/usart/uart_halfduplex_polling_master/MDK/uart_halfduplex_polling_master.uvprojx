# Keil uVision project uart_halfduplex_polling_master.uvprojx, settings and files
target uart_halfduplex_polling_master_Debug (5060020::V5.06 (build 20)::ARMCC)
  device: HC32M423KATB HDSC
  pack: HDSC.HC32M423.1.0.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ESEL ELITTLE
  output: uart_halfduplex_polling_master
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __DEBUG,HC32M423,USE_DDL_DRIVER
  c misc: --diag_suppress=186,66
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;..\..\..\..\bsp\ev_hc32m423_lqfp64;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1FFFE000 size 0x4000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32m423.s
    ../../../../mcu/common/: system_hc32m423.c
  group source
    ../source/: main.c
  group driver
    ../../../../driver/src/: hc32m423_icg.c hc32m423_clk.c hc32m423_pwc.c hc32m423_efm.c hc32m423_usart.c hc32m423_utility.c hc32m423_gpio.c hc32m423_interrupts.c
  group ev_hc32m423_lqfp64
    ../../../../bsp/ev_hc32m423_lqfp64/: ev_hc32m423_lqfp64.c
  group Readme
    ../: Readme.txt
target uart_halfduplex_polling_master_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32M423KATB HDSC
  pack: HDSC.HC32M423.1.0.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFE000,0x4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ESEL ELITTLE
  output: uart_halfduplex_polling_master +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: HC32M423,USE_DDL_DRIVER
  c misc: --diag_suppress=186,66
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1FFFE000 size 0x4000
  link misc: --keep=*Handler
software components: CMSIS:CORE 5.0.1
