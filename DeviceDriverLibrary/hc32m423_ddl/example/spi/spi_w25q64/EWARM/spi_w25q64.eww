<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\spi_w25q64.ewp</path>
  </project>
  <batchBuild/>
</workspace>


